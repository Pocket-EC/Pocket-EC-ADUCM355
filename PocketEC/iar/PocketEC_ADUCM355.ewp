# IAR project PocketEC_ADUCM355.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM355 AnalogDevices ADUCM355
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: CHIPSEL_M355
  ICCARM.CCIncludePath2: ..\..\common; ..\..\inc; ..\..\common\ad5940lib; ..\..\common\IAR
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PocketEC_ADUCM355.srec
  ILINK.IlinkOutputFile: PocketEC.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../: AD5940Main.c Amperometric.c Amperometric.h main.c PocketEC.c PocketEC.h UART.c UART.h
  group common
    ../../common/ad5940lib/: ad5940.c
    ../../common/: ADuCM355Port.c ClkLib.c ClkLib.h DioLib.c DioLib.h IntLib.c IntLib.h PwrLib.c PwrLib.h RstLib.c RstLib.h UrtLib.c UrtLib.h
  group startup
    ../../common/IAR/: retarget.c startup_ADuCM355.c
    ../../common/: system_ADuCM355.c
